r1 1 2 2.2G
R2 2 0 4k
R3 2 3 0.1Meg
R4 2 3 1MEG
IQ 0 1 DC 50e-3
i2 0 2 DC 100e-3
VCC 3 0 DC 230
v2 1 2 105
